# Keil uVision project opl1000_app_m3.uvprojx, settings and files
target OPL1000_APP (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: opl1000_app_m3 +hex
  AfterMake: .\opl1000_app_m3.bat $L !L @L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OPL1000_APS __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __NL1000_An__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ __noRTL_SIMULATION__ __WIFI_AUTO_CONNECT__
  c misc: --preinclude=sys_common.h
  c include: ..\..\SDK\APS\apps\le_app\cmd_app;..\..\SDK\APS\apps\le_app\mtc_app;..\..\SDK\APS\apps\le_app\pts_app;..\..\SDK\APS\driver\chip\opl1000\hal_auxadc;..\..\SDK\APS\driver\chip\opl1000\hal_dbg_uart;..\..\SDK\APS\driver\chip\opl1000\hal_dma;..\..\SDK\APS\driver\chip\opl1000\hal_i2c;..\..\SDK\APS\driver\chip\opl1000\hal_patch;..\..\SDK\APS\driver\chip\opl1000\hal_pwm;..\..\SDK\APS\driver\chip\opl1000\hal_spi;..\..\SDK\APS\driver\chip\opl1000\hal_system;..\..\SDK\APS\driver\chip\opl1000\hal_tick;..\..\SDK\APS\driver\chip\opl1000\hal_tmr;..\..\SDK\APS\driver\chip\opl1000\hal_uart;..\..\SDK\APS\driver\chip\opl1000\hal_vic;..\..\SDK\APS\driver\chip\opl1000\hal_wdt;..\..\SDK\APS\driver\chip\opl1000\securityipdriver;..\..\SDK\APS\driver\CMSIS\Include;..\..\SDK\APS\driver\CMSIS\Device\opl1000\Include;..\..\SDK\APS\FreeRtos\Source\include;..\..\SDK\APS\FreeRtos\Source\portable\Keil\ARM_CM3;..\..\SDK\APS\middleware\netlink\at;..\..\SDK\APS\middleware\netlink\ble_controller_layer\inc;..\..\SDK\APS\middleware\netlink\cli;..\..\SDK\APS\middleware\netlink\common\sys_api;..\..\SDK\APS\middleware\netlink\common\sys_api\rom_if;..\..\SDK\APS\middleware\netlink\common\sys_ctrl;..\..\SDK\APS\middleware\netlink\controller_task;..\..\SDK\APS\middleware\netlink\data_flow;..\..\SDK\APS\middleware\netlink\diag_task;..\..\SDK\APS\middleware\netlink\le_stack;..\..\SDK\APS\middleware\netlink\msg;..\..\SDK\APS\middleware\netlink\mw_fim;..\..\SDK\APS\middleware\netlink\mw_ota;..\..\SDK\APS\middleware\netlink\ps_task;..\..\SDK\APS\middleware\netlink\wifi_controller_layer;..\..\SDK\APS\middleware\netlink\wifi_controller_layer\rom_if;..\..\SDK\APS\middleware\netlink\wifi_mac;..\..\SDK\APS\middleware\third_party\lwip-2.0.3\;..\..\SDK\APS\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\SDK\APS\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\SDK\APS\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\SDK\APS\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\SDK\APS\middleware\third_party\mbedtls\include;..\..\SDK\APS\middleware\third_party\tinycrypt\include;..\..\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\ap;..\..\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\common;..\..\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\crypto;..\..\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eap_common;..\..\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eap_peer;..\..\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_auth;..\..\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_supp;..\..\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\l2_packet;..\..\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\radius;..\..\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\wps;..\..\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant\dbus;..\..\SDK\APS\project\common;..\..\SDK\APS\project\opl1000\boot_sequence;..\..\SDK\APS\project\opl1000\include;..\..\SDK\APS\project\opl1000\startup;..\..\SDK\APS_PATCH\apps\le_app\include;..\..\SDK\APS_PATCH\driver\chip\opl1000\hal_auxadc;..\..\SDK\APS_PATCH\driver\chip\opl1000\hal_dbg_uart;..\..\SDK\APS_PATCH\driver\chip\opl1000\hal_i2c;..\..\SDK\APS_PATCH\driver\chip\opl1000\hal_pwm;..\..\SDK\APS_PATCH\driver\chip\opl1000\hal_spi;..\..\SDK\APS_PATCH\driver\chip\opl1000\hal_system;..\..\SDK\APS_PATCH\driver\chip\opl1000\hal_uart;..\..\SDK\APS_PATCH\driver\chip\opl1000\hal_vic;..\..\SDK\APS_PATCH\driver\chip\opl1000\securityipdriver;..\..\SDK\APS_PATCH\middleware\netlink\at;..\..\SDK\APS_PATCH\middleware\netlink\ble_controller_layer\inc;..\..\SDK\APS_PATCH\middleware\netlink\cli;..\..\SDK\APS_PATCH\middleware\netlink\common\sys_api;..\..\SDK\APS_PATCH\middleware\netlink\controller_task;..\..\SDK\APS_PATCH\middleware\netlink\data_flow;..\..\SDK\APS_PATCH\middleware\netlink\diag_task;..\..\SDK\APS_PATCH\middleware\netlink\le_stack\patch;..\..\SDK\APS_PATCH\middleware\netlink\msg;..\..\SDK\APS_PATCH\middleware\netlink\mw_fim;..\..\SDK\APS_PATCH\middleware\netlink\ps_task;..\..\SDK\APS_PATCH\middleware\netlink\wifi_controller_layer;..\..\SDK\APS_PATCH\middleware\netlink\wifi_controller_layer\rom_if;..\..\SDK\APS_PATCH\middleware\netlink\wifi_mac;..\..\SDK\APS_PATCH\middleware\third_party\httpclient;..\..\SDK\APS_PATCH\middleware\third_party\lwip-2.0.3;..\..\SDK\APS_PATCH\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\SDK\APS_PATCH\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\SDK\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\SDK\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\SDK\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\SDK\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\SDK\APS_PATCH\project\opl1000\include;..\..\SDK\APS_PATCH\project\opl1000\startup;.\src;.\src\btn_press_ctrl;.\src\iot_data;.\src\smart_sleep;.\src\tcp_client;.\src\uart
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
  scatter file: .\opl1000_app_m3.sct
  link misc: --datacompressor off --entry=__Patch_EntryPoint
  group src
    ./src/: main_patch.c blewifi_app.c blewifi_common.c blewifi_ctrl.c blewifi_data.c blewifi_server_app.c blewifi_server_app_gatt.c blewifi_ctrl_http_ota.c blewifi_http_ota.c blewifi_ble_api.c blewifi_wifi_api.c app_at_cmd.c mw_fim_default_group11_project.c
  group iot_data
    ./src/iot_data/: iot_data.c iot_rb_data.c
  group object
    ../../SDK/APS/targets/opl1000/object/: symdefs.o
    ../../SDK/APS/targets/opl1000/Output/Objects/: opl1000_patch_m3.lib opl1000_sdk_m3.lib
  group btn_press_ctrl
    ./src/btn_press_ctrl/: btn_press_ctrl.c
  group smart_sleep
    ./src/smart_sleep/: smart_sleep.c
  group tcp_client
    ./src/tcp_client/: tcp_client.c
  group uart
    ./src/uart/: uart.c
target OPL1000_APP_Transparent (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: opl1000_app_m3_transparent +hex
  AfterMake: .\opl1000_app_m3.bat $L !L @L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OPL1000_APS __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __NL1000_An__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ __noRTL_SIMULATION__ __WIFI_AUTO_CONNECT__ __BLEWIFI_TRANSPARENT__
  c misc: --preinclude=sys_common.h
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
  scatter file: .\opl1000_app_m3.sct
  link misc: --datacompressor off --entry=__Patch_EntryPoint
